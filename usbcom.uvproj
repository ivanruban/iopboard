# Keil uVision project usbcom.uvproj, settings and files
target iopBoard (ARM-ADS)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: usbcom +hex
  c flags: Optim=1 wLevel=2
  c include: .
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group usbcom
    ./: main.c syslog.c Startup.s
    ./usbterminal/microrl/: microrl.c
    ./hw/uart/: uart.c
    ./hw/AD9826/: ad9826.c
    ./hw/usb/: cdcuser.c usbcore.c usbdesc.c usbhw.c usbuser.c
    ./usbterminal/: usbterminal.c vcom.c
